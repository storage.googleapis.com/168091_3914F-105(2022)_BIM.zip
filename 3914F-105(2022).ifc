Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-19T22:46:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 19 22:46:21 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{F900E45B-EE0C-46DC-8AAD-4851D803C05F}\ifc * Database version: 5507 * Database creation date: Wed Jan 19 22:46:20 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 19 22:46:20 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 19 22:46:20 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3914F-105 Washbasin faucet, 3914F-105(2022):3914F-105 Washbasin faucet:464269
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 160.3 mm; NominalHeight: 157 mm; NominalWidth: 49 mm
Type - General - Author: BIMStone; BIMObjectName: 3914F-105(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1413; EAN Number: 6414150100062; EN Standard: EN 817; Sales Package dimensions (LxWxH): 380 x 180 x 74; Sales Package gross weight: 1.600 kg; Sales Package package weight: 0.2202 kg; URL Declaration of Conformity: http://static.oras.com/DoC/3914F-105; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/3914F-105/original; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/3914F-105; Dimension Drawing URL: http://static.oras.com/dimdrw/3914F-105; FDV Document URL: http://www.oras.com/datasheet/3914F-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3914F-105; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/3914F-105; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/3914F-105; Model: 3914F-105 Washbasin faucet; Name_en: 3914F-105 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 3914F-105; Product Family: Oras Saga Eco; Product Image URL: http://static.oras.com/image/3914F-105; Product URL: http://static.oras.com/3914F-105; Spare-Part Information URL: http://static.oras.com/sp/3914F-105; Technical DataSheet URL: http://www.oras.com/datasheet/3914F-105/en; Type Name: 3914F-105 Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Pop-up waste with draw-rod; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Noise Class: I (ISO 3822) Oras lab.; Pressure Loss With Flow 01ls: 200000 Pa; Spout Projection: 110 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3914F-105(2022); Features: Single-lever;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3914F-105; Name: 3914F-105 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 105x160x250 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3914F-105; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3914F-105 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0418079 m2; Volume: 0.00123766 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3914F-105(2022): 3914F-105 Washbasin faucet; Family and Type: 3914F-105(2022): 3914F-105 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3914F-105(2022): 3914F-105 Washbasin faucet; Type Id: 3914F-105(2022): 3914F-105 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
